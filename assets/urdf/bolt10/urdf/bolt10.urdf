Commit message: update

File: assets/urdf/bolt10/urdf/bolt10.urdf (robot description, URDF)
Before this commit: robot bolt10_urdf, 11 links, 10 joints
Links:
- link base_link: mass 1.055 -> 0.556324
